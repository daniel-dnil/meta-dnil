require mediastreamer2.inc

LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=c46082167a314d785d012a244748d803"
